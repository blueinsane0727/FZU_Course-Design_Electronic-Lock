# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\App;.\Driver
  group Hardware
    ./Hardware/: 24c02.c 24c02.h beep.c beep.h MatrixKey.c MatrixKey.h Motor.c Motor.h Nixie.c Nixie.h
  group Driver
    ./Driver/: Delay.c Delay.h iic.c iic.h timer0.c timer0.h
  group App
    ./App/: main.c STARTUP.A51
